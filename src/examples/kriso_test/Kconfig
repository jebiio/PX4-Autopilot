## src/examples/kriso_test/Kconfig
```kconfig
menuconfig EXAMPLES_KRISO_TEST
	bool "kriso_test"
	default n
	---help---
		Enable support for kriso_test
```
